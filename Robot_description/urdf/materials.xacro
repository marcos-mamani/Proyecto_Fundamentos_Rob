Commit message: Update materials.xacro

File: Robot_description/urdf/materials.xacro (robot description, xacro)
@@ -4,3 +4,6 @@
   <color rgba="0.700 0.700 0.700 1.000"/>
 </material>
+<material name="blue">
+  <color rgba="0.000 0.000 1.000 1.000"/>
+</material>
 </robot>
